# Keil uVision project LD3320_Demo.uvproj, settings and files
target LD3320_Demo (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LD3320_Demo +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS\CoreSupport;..\..\CMSIS\STM32F10x;..\..\Hardware\inc;..\..\Libraries\inc;..\..\user\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../../user/src/: main.c stm32f10x_it.c
  group Hardware
    ../../Hardware/src/: LD3320_main.c LDChip.c Reg_RW.c LED.C
  group startup
    ../../startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../../CMSIS/STM32F10x/: system_stm32f10x.c
    ../../CMSIS/CoreSupport/: core_cm3.c
  group Description
    ../../Description/: Description.txt
  group Libraries
    ../../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c
